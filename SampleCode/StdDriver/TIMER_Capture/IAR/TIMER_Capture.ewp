# IAR project TIMER_Capture.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC1311AE series Nuvoton NUC1311AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC1311\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TIMER_Capture.bin
  ILINK.IlinkOutputFile: TIMER_Capture.out
  ILINK.IlinkIcfFile: TIMER_Capture.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1311/Source/IAR/: startup_NUC1311.s
    ../../../../Library/Device/Nuvoton/NUC1311/Source/: system_NUC1311.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c timer.c uart.c
  group User
    ../: main.c
