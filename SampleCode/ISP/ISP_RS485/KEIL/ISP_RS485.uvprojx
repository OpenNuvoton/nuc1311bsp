# Keil uVision project ISP_RS485.uvprojx, settings and files
target ISP_RS485 (6160000::V6.16::ARMCLANG)
  device: NUC1311LD2AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.22
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x11000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: NUC1311_ISP_RS485_PB4_PB5_PA8
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC1311\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_NUC1311.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1311/Source/: system_NUC1311.c
    ../../../../Library/Device/Nuvoton/NUC1311/Source/ARM/: startup_NUC1311.s
  group User
    ../: main.c FMC_USER.c ISP_USER.c targetdev.c uart_transfer.c
