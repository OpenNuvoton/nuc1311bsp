# IAR project FMC_MultiBoot.ewp, settings and files
configuration FMC_MultiBoot (ARM)
  General.OGChipSelectEditMenu: NUC1311AE series Nuvoton NUC1311AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC1311\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: FMC_MultiBoot.bin
  ILINK.IlinkOutputFile: FMC_MultiBoot.out
  ILINK.IlinkIcfFile: FMC_MultiBoot.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration FMC_Boot0 (ARM)
  as the first configuration, except:
configuration FMC_Boot1 (ARM)
  as the first configuration, except:
configuration FMC_Boot2 (ARM)
  as the first configuration, except:
configuration FMC_Boot3 (ARM)
  as the first configuration, except:
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1311/Source/IAR/: startup_NUC1311.s
    ../../../../Library/Device/Nuvoton/NUC1311/Source/: system_NUC1311.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c
  group User
    ../: main.c
